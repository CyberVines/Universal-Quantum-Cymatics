options:
  parameters:
    author: Justin Ried
    category: Custom
    description: Radio TX
    generate_options: qt_gui
    id: Radio_TX
    output_language: python
    realtime_scheduling: '1'
    title: Radio Tx
  states: {}

blocks:
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(48e3)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(480e3)
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '22000'
    decim: '1'
    gain: '5'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: '462725000'
    gain0: '30'
    if_gain0: '100'
    sample_rate: int(48e3)
    sync: pc_clock
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '5'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0_0, '0']
- [audio_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
