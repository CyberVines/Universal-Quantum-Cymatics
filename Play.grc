options:
  parameters:
    author: Justin Ried
    category: Custom
    generate_options: qt_gui
    id: Play_TX
    output_language: python
    title: Play_TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /root/Desktop/CV
    repeat: 'False'
    type: complex
  states: {}
- name: osmosdr_sink_1
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: '462725000'
    gain0: '10'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*4
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', osmosdr_sink_1, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
